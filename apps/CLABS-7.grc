<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CLABS_7_init</value></param>
<param><key>title</key><value>USRP DSP Operation, Program #CLABS-7A</value></param>
<param><key>author</key><value>Nick Foster</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_predistorter</value></param>
<param><key>value</key><value>expanduser("~") + "/rn13_files/" + "Predistort.txt"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>select</value></param>
<param><key>value</key><value>selector_chooser</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>selector_chooser</value></param>
<param><key>label</key><value>Input source</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>initial_select</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>External</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Internal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 0,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_select</value></param>
<param><key>label</key><value>Initial selection</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_baseband_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>value</key><value>75.e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>value</key><value>75.e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>label</key><value>RF in gain (dB)</value></param>
<param><key>value</key><value>initial_rxgain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 2,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>digital_input_gain</value></param>
<param><key>label</key><value>Digital input gain (linear)</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 7,0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>off_switch</value></param>
<param><key>label</key><value>Output</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>On</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Off</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
</block>
<block>
<key>gmrr_rn13_gmrr_waveform_src</key>
<param><key>id</key><value>gmrr_rn13_gmrr_waveform_src_0</value></param>
<param><key>filename</key><value>filename</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(mod_bw_slider)/samp_rate</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>int(mod_type_chooser==3)</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>squelch</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>carrier_level</value></param>
<param><key>label</key><value>Carrier level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 7,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mod_level</value></param>
<param><key>label</key><value>Modulation level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 6,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>vpredistorter_title</value></param>
<param><key>label</key><value>Predistorter Title</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Wat</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@3: 1,0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sig_samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>label</key><value>Squelch value (dBfs)</value></param>
<param><key>value</key><value>-60</value></param>
<param><key>start</key><value>-90</value></param>
<param><key>stop</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@2: 1,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txfreq_slider</value></param>
<param><key>label</key><value>Predriver output freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>txfreq</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 1,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>envelope_gain</value></param>
<param><key>label</key><value>Final gain (linear)</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 4,0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mod_wave_chooser</value></param>
<param><key>label</key><value>Modulation waveform</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Constant</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Sine wave</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>label2</key><value>Triangle wave</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>label3</key><value>Square wave</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 2,0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mod_type_chooser</value></param>
<param><key>label</key><value>Modulation type</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>CW</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Phase mod</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>label2</key><value>Amplitude mod</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>label3</key><value>Downloadable waveform</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 1,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_max_ampl</value></param>
<param><key>label</key><value>Maximum amplitude</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 5,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>str("filename")</value></param>
<param><key>value</key><value>expanduser("~") + "/rn13_files/" + "DLWF.txt"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>predistorter</value></param>
<param><key>label</key><value>Predistorter filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>initial_predistorter</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@3: 0,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_N</value></param>
<param><key>label</key><value>Number of averages</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 2,0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>baseband_gain</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>envelope_gain</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0]*int(final_delay) +[1-(final_delay%1)]  + [final_delay%1]+ [0]*int(100-final_delay)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0]*int(drive_delay) + [1-(drive_delay%1)]  +[drive_delay%1]+ [0]*int(100-drive_delay)</value></param>
</block>
<block>
<key>gmrr_rn13_predistorter</key>
<param><key>id</key><value>gmrr_rn13_predistorter_0</value></param>
<param><key>filename</key><value>predistorter</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_rxgain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_txgain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mod_freq</value></param>
<param><key>label</key><value>Modulation frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-50000</value></param>
<param><key>stop</key><value>50000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 3,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tone_freq</value></param>
<param><key>label</key><value>Offset frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 4,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>predriver_delay</value></param>
<param><key>label</key><value>Predriver delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@4: 1,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>drive_delay</value></param>
<param><key>label</key><value>Drive delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@4: 3,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>baseband_gain</value></param>
<param><key>label</key><value>Driver gain (linear)</value></param>
<param><key>value</key><value>initial_baseband_gain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 5,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>final_delay</value></param>
<param><key>label</key><value>Final delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@4: 2,0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0 B:AB</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request_t(rf_freq=txfreq_slider, dsp_freq=0, rf_freq_policy=uhd.tune_request.POLICY_MANUAL, dsp_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>0</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>ant1</key><value>TXA</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain</value></param>
<param><key>label</key><value>Predriver out gain (dB)</value></param>
<param><key>value</key><value>initial_txgain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 3,0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_grid_widget</value></param>
<param><key>num_tabs</key><value>6</value></param>
<param><key>label0</key><value>RF controls</value></param>
<param><key>label1</key><value>Test modulator controls</value></param>
<param><key>label2</key><value>Envelope/phase detection</value></param>
<param><key>label3</key><value>Predistortion</value></param>
<param><key>label4</key><value>Delays</value></param>
<param><key>label5</key><value>Calibration</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>2 if off_switch==1 else select</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>lo</key><value>0</value></param>
<param><key>hi</key><value>1</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0]*int(predriver_delay) + [1-(predriver_delay%1)]  + [predriver_delay%1]+[0]*int(100-predriver_delay)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mod_bw_slider</value></param>
<param><key>label</key><value>Downloadable modulation sample rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>stop</key><value>samp_rate*50</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@1: 8,0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>label</key><value>&lt;b&gt;USRP DSP Operation, Program #CLABS-7A&lt;/b&gt;&lt;br&gt;&lt;b&gt;RF input spectrum&lt;/b&gt;</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>_vpredistorter_title_label</value></param>
<param><key>function_name</key><value>setText</value></param>
<param><key>function_args</key><value>str(self.gmrr_rn13_predistorter_0.get_title())</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>RF input spectrum</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>rxfreq_slider</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>calibrate_average_probe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>calibrate_K</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>calibrate_K</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>analog_phase_modulator_fc</key>
<param><key>id</key><value>analog_phase_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1/(2**0.5)</value></param>
</block>
<block>
<key>analog_phase_modulator_fc</key>
<param><key>id</key><value>analog_phase_modulator_fc_0_0</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>gmrr_rn13_gmrr_test_src</key>
<param><key>id</key><value>test_src</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mod_type</key><value>mod_wave_chooser</value></param>
<param><key>mode</key><value>min(2,mod_type_chooser)</value></param>
<param><key>carrier_freq</key><value>tone_freq</value></param>
<param><key>mod_freq</key><value>mod_freq</value></param>
<param><key>mod_level</key><value>mod_level</value></param>
<param><key>carrier_level</key><value>carrier_level</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1/(2**0.5)</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request_t(rf_freq=rxfreq_slider, dsp_freq=0, rf_freq_policy=uhd.tune_request.POLICY_MANUAL, dsp_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>rxgain</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>avg</key><value>0.01</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>avg</key><value>0.01</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxfreq_slider</value></param>
<param><key>label</key><value>RF input freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>rxfreq</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@0: 0,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_min_ampl</value></param>
<param><key>label</key><value>Minimum amplitude</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 4,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_num_steps</value></param>
<param><key>label</key><value>Number of amplitude steps</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 6,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_fudge_factor</value></param>
<param><key>label</key><value>Fudge factor</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 7,0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>calibrate_K</value></param>
<param><key>label</key><value>Number of samples per average</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>gui_hint</key><value>tab_grid_widget@5: 1,0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>test_src</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gmrr_rn13_gmrr_waveform_src_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>gmrr_rn13_predistorter_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>gmrr_rn13_predistorter_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>gmrr_rn13_predistorter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>gmrr_rn13_predistorter_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>analog_phase_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmrr_rn13_predistorter_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gmrr_rn13_predistorter_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmrr_rn13_predistorter_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gmrr_rn13_predistorter_0</source_block_id><sink_block_id>fir_filter_xxx_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>calibrate_average_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_phase_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_phase_modulator_fc_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test_src</source_block_id><sink_block_id>blocks_complex_to_arg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0</source_block_id><sink_block_id>analog_phase_modulator_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
