<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CLABS_3_init</value></param>
<param><key>title</key><value>USRP-I Demonstration, Program #JBC-3</value></param>
<param><key>author</key><value>Nick Foster</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>select</value></param>
<param><key>value</key><value>selector_chooser</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>value</key><value>75.e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>value</key><value>75.e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txfreq_slider</value></param>
<param><key>label</key><value>Predriver output freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>txfreq</value></param>
<param><key>gui_hint</key><value>9,0</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>label</key><value>&lt;b&gt;RF input spectrum&lt;/b&gt;</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>6,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxgain_slider</value></param>
<param><key>label</key><value>RF in gain (dB)</value></param>
<param><key>value</key><value>rxgain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>envelope_gain</value></param>
<param><key>label</key><value>Final gain (linear)</value></param>
<param><key>value</key><value>3</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain_slider</value></param>
<param><key>label</key><value>Predriver out gain (dB)</value></param>
<param><key>value</key><value>txgain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_select</value></param>
<param><key>label</key><value>Initial selection</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseband_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0 B:A</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>txfreq_slider</value></param>
<param><key>gain0</key><value>txgain_slider</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>0</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>ant1</key><value>TXA</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>envelope_gain</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>lo</key><value>0</value></param>
<param><key>hi</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>baseband_gain</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>RF input spectrum</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>rxfreq_slider</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>7,0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>select</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>rxfreq_slider</value></param>
<param><key>gain0</key><value>rxgain_slider</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>baseband_gain_slider</value></param>
<param><key>label</key><value>Baseband gain (linear)</value></param>
<param><key>value</key><value>baseband_gain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>5,0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>not select</value></param>
</block>
<block>
<key>gmrr_rn13_gmrr_waveform_src</key>
<param><key>id</key><value>gmrr_rn13_gmrr_waveform_src_0</value></param>
<param><key>filename</key><value>/home/nick/Desktop/DL10.TXT</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>mod_bw_slider/(samp_rate/50)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxfreq_slider</value></param>
<param><key>label</key><value>RF input freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>rxfreq</value></param>
<param><key>gui_hint</key><value>8,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mod_bw_slider</value></param>
<param><key>label</key><value>Test waveform modulation bandwidth</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>start</key><value>100</value></param>
<param><key>stop</key><value>samp_rate</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>10,0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>selector_chooser</value></param>
<param><key>label</key><value>Input source</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>initial_select</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>10-tone Waveform</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>RF Input</value></param>
<param><key>gui_hint</key><value>11,0</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmrr_rn13_gmrr_waveform_src_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
